# Keil uVision project BH-F103.uvprojx, settings and files
target LDC (5060960::V5.06 update 7 (build 960)::.\ARMGCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\User\wifi;..\..\User\eeprom;..\..\Libraries\FWlib\inc;..\..\LVGL;..\..\LVGL\lvgl_driver;..\..\LVGL\src;..\..\LVGL\src\core;..\..\LVGL\src\draw;..\..\LVGL\src\extra;..\..\LVGL\src\font;..\..\LVGL\src\hal;..\..\LVGL\src\misc;..\..\LVGL\src\widgets;..\..\LVGL\examples
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_it.c palette.c
    ../../User/usart/: bsp_usart.c
    ../../User/led/: bsp_led.c
    ../../User/flash/: bsp_spi_flash.c
    ../../User/Lcd/: bsp_ili9341_lcd.c
    ../../User/lcd/: bsp_xpt2046_lcd.c
    ../../User/font/: fonts.c
    ../../User/wifi/: bsp_esp8266.c
    ../../User/eeprom/: bsp_at24c02.c
  group DOC
    ../../Doc/: readme.txt
  group LVGL Source
    ../../LVGL/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
    ../../LVGL/src/draw/arm2d/: lv_gpu_arm2d.c
    ../../LVGL/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    ../../LVGL/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    ../../LVGL/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
    ../../LVGL/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
    ../../LVGL/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.c
    ../../LVGL/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../../LVGL/src/extra/: lv_extra.c
    ../../LVGL/src/extra/widgets/animimg/: lv_animimg.c
    ../../LVGL/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../../LVGL/src/extra/widgets/chart/: lv_chart.c
    ../../LVGL/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../../LVGL/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../../LVGL/src/extra/widgets/keyboard/: lv_keyboard.c
    ../../LVGL/src/extra/widgets/led/: lv_led.c
    ../../LVGL/src/extra/widgets/list/: lv_list.c
    ../../LVGL/src/extra/widgets/menu/: lv_menu.c
    ../../LVGL/src/extra/widgets/meter/: lv_meter.c
    ../../LVGL/src/extra/widgets/msgbox/: lv_msgbox.c
    ../../LVGL/src/extra/widgets/span/: lv_span.c
    ../../LVGL/src/extra/widgets/spinbox/: lv_spinbox.c
    ../../LVGL/src/extra/widgets/spinner/: lv_spinner.c
    ../../LVGL/src/extra/widgets/tabview/: lv_tabview.c
    ../../LVGL/src/extra/widgets/tileview/: lv_tileview.c
    ../../LVGL/src/extra/widgets/win/: lv_win.c
    ../../LVGL/src/extra/themes/basic/: lv_theme_basic.c
    ../../LVGL/src/extra/themes/default/: lv_theme_default.c
    ../../LVGL/src/extra/themes/mono/: lv_theme_mono.c
    ../../LVGL/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../../LVGL/src/extra/others/gridnav/: lv_gridnav.c
    ../../LVGL/src/extra/others/imgfont/: lv_imgfont.c
    ../../LVGL/src/extra/others/monkey/: lv_monkey.c
    ../../LVGL/src/extra/others/msg/: lv_msg.c
    ../../LVGL/src/extra/others/snapshot/: lv_snapshot.c
    ../../LVGL/src/extra/libs/bmp/: lv_bmp.c
    ../../LVGL/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../../LVGL/src/extra/libs/freetype/: lv_freetype.c
    ../../LVGL/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../../LVGL/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../../LVGL/src/extra/libs/png/: lodepng.c lv_png.c
    ../../LVGL/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../../LVGL/src/extra/libs/rlottie/: lv_rlottie.c
    ../../LVGL/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../../LVGL/src/extra/layouts/flex/: lv_flex.c
    ../../LVGL/src/extra/layouts/grid/: lv_grid.c
    ../../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
    ../../LVGL/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    ../../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
    ../../LVGL/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL Config
    ../../LVGL/: lv_conf.h
  group LVGL Port
    ../../LVGL/lvgl_driver/: lv_port_disp.c lv_port_indev.c
  group LVGL APP
    ../../LVGL/examples/widgets/btn/: lv_example_btn_1.c
